# Keil uVision project LED-REG.uvprojx, settings and files
target LED-REG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED-REG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\LED flash register version;.\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c startup_stm32f429_439xx.s stm32f4xx.h
    ./GPIO/: stm_gpio.c stm_gpio.h
